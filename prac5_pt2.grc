options:
  parameters:
    author: Miguel Buitrago
    copyright: UIS
    description: montaje de modulacion PWM
    generate_options: qt_gui
    id: Prac5_pt2
    output_language: python
    title: Modulador PWM
  states: {}

blocks:
- name: Amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '0'
    step: '0.1'
    stop: '10'
    value: '2'
  states: {}
- name: Offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    start: '-2'
    step: '0.01'
    stop: '2'
    value: '-1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Amplitude
    freq: 10e3
    offset: Offset
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', ModulosEfren_Compara_0, '1']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_1, '0', ModulosEfren_Compara_0, '0']
- [analog_sig_source_x_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
